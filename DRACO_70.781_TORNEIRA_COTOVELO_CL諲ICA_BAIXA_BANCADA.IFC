Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.781_TORNEIRA_COTOVELO_CLÍNICA_BAIXA_BANCADA.IFC
Time: 2023-11-07T20:16:19
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.781_TORNEIRA_COTOVELO_CLÍNICA_BAIXA_BANCADA
In: Default Storey
Material: Latão
PSet_Mass_Property - Mass Measure: 1.64682; Area Measure: 0.0324016 m2; Volume Measure: 0.000193744 m3
